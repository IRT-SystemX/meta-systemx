FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

LOCALVERSION = "-1.0.1_ga+yocto"
SRCBRANCH = "boundary-imx_3.10.17_1.0.1_ga"
SRCREV = "f2136a477c7a81d23cebf859a9d80f2766afa5c2"

