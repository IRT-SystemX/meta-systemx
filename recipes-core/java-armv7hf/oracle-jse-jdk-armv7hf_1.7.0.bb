PR = "r0"
PV_UPDATE = "51"

require oracle-jse-jdk.inc

#TODO : LE METTRE SUR LE SERVER DE L'IRT
SRC_URI = "http://5.196.54.50/jdk-7u51-linux-arm-vfp-hflt.tar.gz"
#SRC_URI = "file://jdk-7u51-linux-arm-vfp-hflt.tar.gz"

SRC_URI[md5sum] = "80e14facc0aa784f44d8f142025dd020"
SRC_URI[sha256sum] = "47273843454755d1bdd3b91ec97c42b1bcdae01af6e42c38413c3d0ff630557a"
